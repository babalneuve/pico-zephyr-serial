## build/Kconfig/Kconfig.shield
```kconfig
osource "c:/users/ext_basver/zephyrproject/bluetooth_mesh/boards/shields/*/Kconfig.shield"
```
